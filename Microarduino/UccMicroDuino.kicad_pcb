# Repository frea14/trabajos-lab-computacion

File README.md:

# trabajos-lab-computacion
Santiago Freaza 2621844
Tomas Factor 2608726

## KiCad design Microarduino/UccMicroDuino.kicad_pcb

Parts:
C1: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: PMLL4148L; D_MiniMELF
D2, D4: 3.6V 1/2mW; D_SOD-123
D3: Led Red; ledSMD
D5: Led Green; ledSMD
J1: Header; PinHeader_1x10_P2.54mm_Vertical
J2: USB_PCB_A; USB_A_UCC
R1: 1.5KΩ 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R5: 330Ω 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 68Ω 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ATtiny85-20S; SOIC-8_5.3x5.3mm_P1.27mm

Connections:
+5V: C1.1, D1.1 (K), D3.2 (A), J1.1, R1.1, U1.8 (VCC)
GND: C1.2, D2.2 (A), D4.2 (A), J1.2, J2.4 (GND), R2.2, R5.2, U1.4 (GND)
unnamed: D1.2 (A), J2.1 (VBUS)
unnamed: D2.1 (K), J2.2 (D-), R1.2, R4.1
unnamed: D3.1 (K), R5.1
unnamed: D4.1 (K), J2.3 (D+), R3.1
unnamed: D5.2 (A), J1.4, U1.5 (AREF/PB0)
unnamed: D5.1 (K), R2.1
unnamed: J1.5, U1.6 (PB1)
unnamed: J1.6, U1.7 (PB2)
unnamed: J1.7, R4.2, U1.2 (XTAL1/PB3)
unnamed: J1.8, R3.2, U1.3 (XTAL2/PB4)
unnamed: J1.9, U1.1 (~RESET/PB5)

Board: 2 copper layers, 45.0 x 53.5 mm, 14 parts (0 on the bottom side), 13 nets.
